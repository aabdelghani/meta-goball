PACKAGECONFIG:append = " sdl2"
